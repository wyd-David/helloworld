# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1,__FPU_USED=1,__CC_ARM
  c include: ..\USER;..\applications;..\devices;..\drivers;..\Libraries\inc;.\DebugConfig;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FATFS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group LIBRARIES
    ../Libraries/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_it.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c arm_cos_f32.c arm_sin_f32.c w25qxx.c spi.c
  group DRIVERS
    ../drivers/: driver_ak8975.c driver_GPS.c driver_led.c driver_mpu6050.c driver_ms5611.c driver_parameter.c driver_pwm_in.c driver_pwm_out.c driver_ultrasonic.c driver_usart.c
  group DEVICES
    ../devices/: device_iic.c device_ak8975.c device_led.c device_mpu6050.c device_ms5611.c device_pwm_in.c device_pwm_out.c device_timer.c device_usart.c
  group APP
    ../applications/: ctrl.c data_transfer.c filter.c height_ctrl.c imu.c init.c main.c mymath.c Optical_Flow.c position_control.c rc.c scheduler.c time.c SCS0009.c
  group FATFS
    ../FATFS/: diskio.c drv_w25qxx.c ff.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
